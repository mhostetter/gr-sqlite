<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sqlite_timed_source</value></param>
<param><key>author</key><value>Matt Hostetter</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import datetime</value></param>
</block>
<block>
<key>sqlite_timed_source</key>
<param><key>id</key><value>sqlite_timed_source_0</value></param>
<param><key>filename</key><value>/tmp/sqlite.db</value></param>
<param><key>vector_column_name</key><value>data</value></param>
<param><key>realtime_factor</key><value>1.0</value></param>
<param><key>db_start_timestamp</key><value>1489428600</value></param>
<param><key>table_name</key><value>table1</value></param>
<param><key>timestamp_column_name</key><value>timestamp</value></param>
</block>
<connection><source_block_id>sqlite_timed_source_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdu</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
