<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sqlite_sink</value></param>
<param><key>author</key><value>Matt Hostetter</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>meta</value></param>
<param><key>value</key><value>{'timestamp': 1489295275, 'frequency': 123.45, 'snr': 21.739012}</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_pdu_set</key>
<param><key>id</key><value>blocks_pdu_set_0</value></param>
<param><key>k</key><value>pmt.intern('timestamp')</value></param>
<param><key>v</key><value>pmt.to_pmt(1489295275)</value></param>
</block>
<block>
<key>blocks_pdu_set</key>
<param><key>id</key><value>blocks_pdu_set_0_0</value></param>
<param><key>k</key><value>pmt.intern('frequency')</value></param>
<param><key>v</key><value>pmt.to_pmt(1743.29)</value></param>
</block>
<block>
<key>blocks_pdu_set</key>
<param><key>id</key><value>blocks_pdu_set_0_0_0</value></param>
<param><key>k</key><value>pmt.intern('snr')</value></param>
<param><key>v</key><value>pmt.to_pmt(24.7274)</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>100</value></param>
<param><key>minsize</key><value>50</value></param>
</block>
<block>
<key>sqlite_sink</key>
<param><key>id</key><value>sqlite_sink_0</value></param>
<param><key>filename</key><value>/tmp/sqlite.db</value></param>
<param><key>fixed_position_columns</key><value>['timestamp']</value></param>
<param><key>vector_column_name</key><value>data</value></param>
<param><key>table_name</key><value>table1</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_pdu_set_0</source_block_id><sink_block_id>blocks_pdu_set_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_pdu_set_0_0</source_block_id><sink_block_id>blocks_pdu_set_0_0_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>blocks_pdu_set_0_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>blocks_pdu_set_0_0_0</source_block_id><sink_block_id>sqlite_sink_0</sink_block_id><source_key>pdus</source_key><sink_key>pdu</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>blocks_pdu_set_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
