<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sqlite_triggered_source</value></param>
<param><key>author</key><value>Matt Hostetter</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>sqlite_triggered_source</key>
<param><key>id</key><value>sqlite_triggered_source_0</value></param>
<param><key>filename</key><value>/tmp/sqlite.db</value></param>
<param><key>vector_column_name</key><value>data</value></param>
<param><key>sql_condition</key><value></value></param>
<param><key>table_name</key><value>table1</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>sqlite_triggered_source_0</sink_block_id><source_key>strobe</source_key><sink_key>trigger</sink_key></connection>
<connection><source_block_id>sqlite_triggered_source_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdu</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
